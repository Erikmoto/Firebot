<?xml version="1.0" encoding="UTF-8"?>
<workspace>
    <project>
        <path>$WS_DIR$\TivaWare_C_Series-2.1.4.178\driverlib\driverlib.ewp</path>
    </project>
    <project>
        <path>$WS_DIR$\Projects\firebot\firebot.ewp</path>
    </project>
    <project>
        <path>$WS_DIR$\Projects\simple_uart\simple_uart.ewp</path>
    </project>
    <batchBuild />
</workspace>
